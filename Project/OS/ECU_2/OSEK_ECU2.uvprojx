# Keil uVision project OSEK_ECU2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example6
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: ..\ECU_2;..\OSEK;..\..\driver_ECU2\ASW;..\..\driver_ECU2\common;..\..\driver_ECU2\HWAL;..\..\driver_ECU2\MCAL;..\..\driver_ECU2\RTE;..\..\driver_ECU2\SERVICE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group OS
    ../OSEK/startup/: keilUvisoin_startup.s
    ../OSEK/: counter.c counter.h hook.c os.h OsekLib.lib OsTypes.h
    ./: OsCfg.c OsCfg.h schedule.c
  group ASW
    ../../driver_ECU2/ASW/: CompressorControlSWC.c CompressorControlSWC.h CoolingControlSWC.c CoolingControlSWC.h FanControlSWC.c FanControlSWC.h NVBlockSWC.c NVBlockSWC.h
  group common
    ../../driver_ECU2/common/: Compiler.h Compiler_Cfg.h Std_Types.h
  group HWAL
    ../../driver_ECU2/HWAL/: IOHwAbCompressor.c IOHwAbCompressor.h IOHwAbFan.c IOHwAbFan.h HwAbMem.c HwAbMem.h
  group MCAL
    ../../driver_ECU2/MCAL/: Pwm.c Pwm.h Fls.c Fls.h
  group RTE
    ../../driver_ECU2/RTE/: RTE.c RTE.h
  group SERVICE
    ../../driver_ECU2/SERVICE/: CommunicationManager.c CommunicationManager.h DiagnosticManager.c DiagnosticManager.h NVMManager.c NVMManager.h
software components: CMSIS:CORE 6.1.0
