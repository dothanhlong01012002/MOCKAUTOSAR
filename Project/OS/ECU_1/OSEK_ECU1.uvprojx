# Keil uVision project OSEK_ECU1.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example6
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: ..\ECU_1;..\OSEK;..\..\driver_ECU1\ASW;..\..\driver_ECU1\common;..\..\driver_ECU1\HWAL;..\..\driver_ECU1\MCAL;..\..\driver_ECU1\RTE;..\..\driver_ECU1\SERVICE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group OS
    ../OSEK/startup/: keilUvisoin_startup.s
    ../OSEK/: counter.c counter.h hook.c os.h OsekLib.lib OsTypes.h
    ./: OsCfg.c OsCfg.h schedule.c
  group ASW
    ../../driver_ECU1/ASW/: EngineSpeedSWC.c EngineSpeedSWC.h TemperatureSensorSWC.c TemperatureSensorSWC.h
  group common
    ../../driver_ECU1/common/: Compiler.h Compiler_Cfg.h Std_Types.h
  group HWAL
    ../../driver_ECU1/HWAL/: IOHwAbSpeedSensor.c IOHwAbSpeedSensor.h IOHwAbTemperatureSensor.c IOHwAbTemperatureSensor.h IOHwAbCan.c IOHwAbCan.h
  group MCAL
    ../../driver_ECU1/MCAL/: Adc.c Adc.h Can.c Can.h
  group RTE
    ../../driver_ECU1/RTE/: RTE.c RTE.h Rte_AppComTX.c Rte_AppComTX.h Rte_AppReadSensor.c Rte_AppReadSensor.h
  group SERVICE
    ../../driver_ECU1/SERVICE/: ComM.c ComM.h Com.c Com.h PduR.c PduR.h
software components: CMSIS:CORE 6.1.0
